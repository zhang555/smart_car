<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>FX15_Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>FX15_Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>DZ10_Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>DZ10_Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>AAuser</name>
    <file>
      <name>$PROJ_DIR$\..\..\user\1init.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\user\1init.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\user\bianmaqi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\user\bianmaqi.H</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\user\CCD.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\user\ccd.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\user\ccd_data_processing.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\user\ccd_data_processing.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\user\futaba_pid.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\user\futaba_pid.H</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\user\isr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\user\isr.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\user\nokia.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\user\nokia.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\user\OLED.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\user\OLED.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\user\upload.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\user\upload.H</name>
    </file>
  </group>
  <group>
    <name>App</name>
    <file>
      <name>$PROJ_DIR$\..\..\App\include.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\App\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\App\MK60_conf.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\App\MK60_conf.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\App\MK60_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\App\MK60_it.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\App\PORT_cfg.h</name>
    </file>
  </group>
  <group>
    <name>Board</name>
    <file>
      <name>$PROJ_DIR$\..\..\Board\VCAN_key.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Board\VCAN_key.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Board\VCAN_LED.C</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Board\VCAN_LED.H</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Board\VCAN_MMA7455.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Board\VCAN_MMA7455.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Board\VCAN_NRF24L0.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Board\VCAN_NRF24L0.h</name>
    </file>
  </group>
  <group>
    <name>Chip</name>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\adc.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\adc_cfg.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\common.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\dma.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\iar.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\misc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\misc.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\MK60_DWT.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\MK60_DWT.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\MK60_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\MK60_flash.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\MK60_ftm.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\MK60_FTM.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\MK60_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\MK60_gpio.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\MK60_gpio_cfg.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\MK60_i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\MK60_i2c.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\MK60_lptmr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\MK60_lptmr.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\MK60_mcg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\MK60_mcg.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\MK60_PIT.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\MK60_PIT.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\MK60_port.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\MK60_port.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\MK60_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\MK60_spi.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\MK60_SysTick.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\MK60_SysTick.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\MK60_uart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\MK60_uart.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\MK60_wdog.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\MK60_wdog.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\kinetis\MK60DZ10.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\startup_MK60DZ10.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\system_MK60DZ10.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\system_MK60DZ10.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\vectors.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\vectors.h</name>
    </file>
  </group>
  <group>
    <name>LIB</name>
    <group>
      <name>CMSIS</name>
    </group>
  </group>
</project>


