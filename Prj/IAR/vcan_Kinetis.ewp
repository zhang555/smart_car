# IAR project vcan_Kinetis.ewp, settings and files
configuration FX15_Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60FX512xxx15 Freescale MK60FX512xxx15
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: DEBUG; ARM_MATH_CM4; MK60F15
  ICCARM.CCIncludePath2: ..\..\App; ..\..\App\Inc; ..\..\Board\Inc; ..\..\Chip\inc; ..\..\Chip\inc\IAR; ..\..\Chip\inc\kinetis; ..\..\Lib\CMSIS\Inc; ..\..\Lib\FatFs; ..\..\Lib\USB
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: vcan_Kinetis.hex
  ILINK.IlinkOutputFile: vcan_Kinetis.out
  ILINK.IlinkIcfFile: config files\vcan_ROM_K60X512.icf
  ILINK.IlinkAdditionalLibs: ..\..\Lib\CMSIS\iar_cortexM4l_math.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FX15_Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; ARM_MATH_CM4; MK60F15
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: config files\vcan_ROM_K60N512.icf
configuration DZ10_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  ICCARM.CCDefines: DEBUG; ARM_MATH_CM4; MK60DZ10
  ICCARM.CCIncludePath2: ..\..\App; ..\..\user; ..\..\Board; ..\..\Chip; ..\..\Chip\kinetis; ..\..\Lib\CMSIS\Inc; ..\..\Lib\FatFs; ..\..\Lib\USB
  ILINK.IlinkIcfFile: config files\vcan_ROM_K60N512.icf
configuration DZ10_Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  ICCARM.CCDefines: NDEBUG; ARM_MATH_CM4; MK60DZ10
  ICCARM.CCIncludePath2: ..\..\App; ..\..\App\Inc; ..\..\Board\Inc; ..\..\Chip\inc; ..\..\Chip\inc\IAR; ..\..\Chip\inc\kinetis; ..\..\Lib\CMSIS\Inc
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: config files\vcan_ROM_K60N512.icf
  group AAuser
    ../../user/: 1init.c 1init.h bianmaqi.c bianmaqi.H CCD.c ccd.h ccd_data_processing.c ccd_data_processing.h futaba_pid.c futaba_pid.H isr.c isr.h nokia.c nokia.h OLED.c OLED.h upload.c upload.H
  group App
    ../../App/: include.h main.c MK60_conf.c MK60_conf.h MK60_it.c MK60_it.h PORT_cfg.h
  group Board
    ../../Board/: VCAN_key.c VCAN_key.h VCAN_LED.C VCAN_LED.H VCAN_MMA7455.c VCAN_MMA7455.h VCAN_NRF24L0.c VCAN_NRF24L0.h
  group Chip
    ../../Chip/: adc.c adc.h adc_cfg.h common.h dma.c dma.h iar.h misc.c misc.h MK60_DWT.c MK60_DWT.h MK60_flash.c MK60_flash.h MK60_ftm.c MK60_FTM.h MK60_gpio.c MK60_gpio.h MK60_gpio_cfg.h MK60_i2c.c MK60_i2c.h MK60_lptmr.c MK60_lptmr.h MK60_mcg.c MK60_mcg.h MK60_PIT.c MK60_PIT.h MK60_port.c MK60_port.h MK60_spi.c MK60_spi.h MK60_SysTick.c MK60_SysTick.h MK60_uart.c MK60_uart.h MK60_wdog.c MK60_wdog.h startup_MK60DZ10.s system_MK60DZ10.c system_MK60DZ10.h vectors.c vectors.h
    ../../Chip/kinetis/: MK60DZ10.h
